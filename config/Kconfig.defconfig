## config/Kconfig.defconfig
```kconfig
# Copyright (c) 2021 The ZMK Contributors
# SPDX-License-Identifier: MIT

if SHIELD_BEDGE65

config ZMK_KEYBOARD_NAME
    default "Bedge65"

endif
```
